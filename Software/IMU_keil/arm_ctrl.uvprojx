# Keil uVision project arm_ctrl.uvprojx, settings and files
target Target_1 (6160000::V6.16::ARMCLANG)
  device: R7FA4M1AB Renesas
  pack: Renesas.RA_DFP.6.3.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: arm_ctrl +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=1 v6Lang=3 v6LangP=6 wLevel=1
  c misc: @./via/rasc_armclang.via
  c include: .\src\UserCode;.\src\UserCode\cpp_main;.\src\UserCode\ICM42688;.\src\UserCode\QMC5883P
  asm misc: --via=./via/rasc_armasm.via
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.cpp hal_warmstart.c
    ./src/UserCode/cpp_main/: cpp_main.cpp cpp_main.h
    ./src/UserCode/ICM42688/: ESKF.c ESKF.h ICM42688.cpp ICM42688.h ICM42688_reg.h
    ./src/UserCode/QMC5883P/: qmc5883p.cpp qmc5883p.h
software components: Flex Software:RA Configuration 1.0.0
